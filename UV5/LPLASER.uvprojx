# Keil uVision project LPLASER.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LPLASER_V3 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\RTE\Device\STM32F103C8;.\RTE;..\APP;..\BSP;..\BSP\cpu2fpga;..\BSP\led;..\BSP\my_rtc;..\BSP\usart;..\BSP\USB;..\BSP\flash;..\BSP\ENC28J60;..\BSP\SPI;..\BSP\UIP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: sch.c app.c
  group BSP
    ../BSP/: bsp.c
    ../BSP/cpu2fpga/: cpu2fpga.c
    ../BSP/flash/: flash.c
    ../BSP/led/: led.c
    ../BSP/my_rtc/: my_rtc.c
    ../BSP/usart/: usart.c
    ../BSP/ENC28J60/: ENC28J60.C
    ../BSP/SPI/: SPI.C
  group UIP
    ../BSP/UIP/: ip_arp_udp_tcp.c simple_server.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
